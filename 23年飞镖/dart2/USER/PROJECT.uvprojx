# Keil uVision project PROJECT.uvprojx, settings and files
target PROJECT (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PROJECT +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\File\API;..\File\BSP;..\File\RM-Types;..\File\STM32_LIB\CMSIS;..\File\STM32_LIB\FWLIB;..\File\TASK;..\File\USER;..\File\TFcard\FATFS\src;..\File\TFcard\TFCard_Driver
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group RM_Types
    ../File/RM-Types/: hitcrt_types.h
  group USER
    ../File/USER/: main.c stm32f4xx_it.c system_stm32f4xx.c bsp_init.c os.c global.c
  group TASK
    ../File/TASK/: systemmonitor.c SD.c
  group API
    ../File/API/: algorithm.c can_control.c usart_control.c
  group BSP
    ../File/BSP/: can.c sys.c tim.c pwm.c verify.c usart.c
  group CMSIS
    ../File/STM32_LIB/CMSIS/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h startup_stm32f40_41xxx.s
  group FWLIB
    ../File/STM32_LIB/FWLIB/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group TF
    ../File/TFcard/FATFS/src/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
    ../File/TFcard/TFCard_Driver/: TF_Card_SPI_DMA.c TF_Card_SPI_DMA.h
